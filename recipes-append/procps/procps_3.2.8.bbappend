PR .= "+fsl_networking"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
